# Keil uVision project RaySRTOS.uvproj, settings and files
target RaySRTOS (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: RaySRTOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\CPU\8051_KEIL;..\..\Kernel
  group Demo
    ./: main.c
  group Kernel
    ../../Kernel/: RaysRTOS.c
  group CPU
    ../../CPU/8051_KEIL/: CPU.c CPU_ASM.asm
