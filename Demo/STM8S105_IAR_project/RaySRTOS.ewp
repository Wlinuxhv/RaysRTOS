# IAR project RaySRTOS.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\..\Kernel\; ..\..\CPU\STM8_IAR\; ..\..\CPU\STM8_IAR\driver; ..\..\CPU\STM8_IAR\driver\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\CPU\STM8_IAR\driver\inc; ..\..\CPU\STM8_IAR\bsp
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RaySRTOS.bin
  ILINK.IlinkOutputFile: RaySrtos.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group CPU
    ../../CPU/STM8_IAR/: CPU.c CPU_ASM.s CPU_CFG.h
  group Driver
    ../../CPU/STM8_IAR/driver/: led.c USART.c
  group Driver/lib
    ../../CPU/STM8_IAR/driver/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group Kernel
    ../../Kernel/: RaysRTOS.c RaysRTOS.h
