# IAR project Backup of RaySRTOS.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\Kernel\; ..\..\CPU\STM8_IAR\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RaySRTOS.srec
  ILINK.IlinkOutputFile: yyy.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group CPU
    ../../CPU/STM8_IAR/: CPU.c CPU_ASM.s CPU_CFG.h
  group Kernel
    ../../Kernel/: RaysRTOS.c RaysRTOS.h
